# Keil uVision project Application.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G455REL7 NSING
  pack: NSING.N32G45x_DFP.1.0.7
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: a +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=MCU.BIN !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\MAIN;..\BSP;..\MIDDLE\SEGGER_RTT_V848\Config;..\MIDDLE\SEGGER_RTT_V848\RTT;..\MIDDLE\GSV2011\userapp;..\MIDDLE\GSV2011\kapi;..\MIDDLE\GSV2011\uapi\gsv2k11_r1_reg;..\MIDDLE\GSV2011\uapi;..\APP;C:\Users\Administrator\AppData\Local\Arm\Packs\NSING\N32G45x_DFP\1.0.7\firmware\CMSIS\core
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group main
    ../MAIN/: main.c interrupt.c gsv2011_config.h
  group bsp
    ../BSP/: BSP.c BSP_LED.c BSP_SWDEBUG.c BSP_SYSTEMCLOCK.c BSP_GM5351A.c BSP_USART.c BSP_GSV2011.c BSP_SPI.c BSP_FPGA.c BSP_NEC.c BSP_FLASH.c BSP_KEY.c BSP_SOFT_USART.c
  group middle/rtt
    ../MIDDLE/SEGGER_RTT_V848/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group middel/gsv/apps
    ../MIDDLE/GSV2011/userapp/: av_common.c av_edid_manage.c av_event_handler.c av_irda_cmd.c av_key_cmd.c av_main.c av_uart_cmd.c
  group middle/gsv/kapi
    ../MIDDLE/GSV2011/kapi/: kapi.c kapi_debug_info.c kernel_fsm.c kernel_status_update.c uapi_function_mapper.c
  group middle/gsv/uapi
    ../MIDDLE/GSV2011/uapi/: gsv2k11.c hal.c uapi.c
  group app
    ../APP/: APP_GSV2011.c APP.c APP_USART.c APP_NEC.c APP_FLASH.c APP_FPGA.c APP_KEY.c APP_LED.c APP_SOFT_USART.c
software components: CMSIS:CORE 5.6.0, Device:N32G45x_StdPeripherals:DMA 1.0.0, Device:N32G45x_StdPeripherals:EXTI 1.0.0, Device:N32G45x_StdPeripherals:FLASH 1.0.0, Device:N32G45x_StdPeripherals:GPIO 1.0.0, Device:N32G45x_StdPeripherals:I2C 1.0.0, Device:N32G45x_StdPeripherals:MISC 1.0.0, Device:N32G45x_StdPeripherals:RCC 1.0.0, Device:N32G45x_StdPeripherals:SPI 1.0.0, Device:N32G45x_StdPeripherals:TIMER 1.0.0, Device:N32G45x_StdPeripherals:USART 1.0.0, Device:Startup 1.0.0, RTOS:device 3.1.5, RTOS:kernel 3.1.5, RTOS:shell 3.1.5
